# Keil uVision project Project_Manuel.uvprojx, settings and files
target Project_Manuel (6070000::V6.7::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: CPUTYPE("Cortex-M3")
  output: Project_Manuel
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: MBED_ROM_START=0x0 TARGET_RELEASE DEVICE_SPI=1 DEVICE_SLEEP=1 TARGET_CORTEX ARM_MATH_CM3 DEVICE_DEBUG_AWARENESS=1 DEVICE_FLASH=1 MULADDC_CANNOT_USE_R7 TOOLCHAIN_ARM_STD DEVICE_ANALOGIN=1 __MBED_CMSIS_RTOS_CM DEVICE_ANALOGOUT=1 MBED_RAM1_START=0x2007c000 DEVICE_RTC=1 TARGET_LIKE_MBED DEVICE_SPISLAVE=1 DEVICE_I2C=1 DEVICE_LOCALFILESYSTEM=1 DEVICE_STDIO_MESSAGES=1 DEVICE_PORTINOUT=1 __CMSIS_RTOS DEVICE_PORTOUT=1 __ASSERT_MSG DEVICE_PORTIN=1 TARGET_NXP_EMAC TARGET_CORTEX_M TARGET_LPC176X TARGET_LPCTarget MBED_MINIMAL_PRINTF DEVICE_SERIAL_FC=1 __MBED__=1 TARGET_MBED_LPC1768 DEVICE_ETHERNET=1 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_MPU=1 MBED_RAM_SIZE=0x8000 DEVICE_WATCHDOG=1 TARGET_M3 MBED_RAM1_SIZE=0x8000 DEVICE_SEMIHOST=1 DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM DEVICE_SERIAL=1 DEVICE_USTICKER=1 MBED_RAM_START=0x10000000 MBED_ROM_SIZE=0x80000 TARGET_NXP __CORTEX_M3 TARGET_LIKE_CORTEX_M3 MBED_BUILD_TIMESTAMP=1670605874.361282 TARGET_NAME=LPC1768 DEVICE_EMAC=1 DEVICE_USBDEVICE=1 DEVICE_RESET_REASON=1 DEVICE_CAN=1 TOOLCHAIN_ARMC6 DEVICE_I2CSLAVE=1 TARGET_LPC1768 DEVICE_PWMOUT=1
  c misc: -c -mcpu=cortex-m3 -mthumb -Wno-armcc-pragma-push-pop -fshort-wchar --target=arm-arm-none-eabi -fno-exceptions -fshort-enums -Wno-reserved-user-defined-literal -Wno-deprecated-register -fno-rtti -fno-c++-static-destructors -Wno-armcc-pragma-anon-unions -fdata-sections -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;DebounceIn;HCSR04;HC_SR04_Ultrasonic_Library;USBDevice;USBDevice/USBAudio;USBDevice/USBDevice;USBDevice/USBHID;USBDevice/USBMIDI;USBDevice/USBMSD;USBDevice/USBSerial;USBDevice/targets/TARGET_NXP;mbed;mbed-rtos;mbed-rtos/rtos;mbed-rtos/rtx/TARGET_CORTEX_M;mbed-rtos/targets/TARGET_NXP;mbed/TARGET_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: --show_full_path --legacyalign --any_contingency --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_ROM_SIZE=0x80000" --predefine="-DMBED_RAM_START=0x10000000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DMBED_RAM1_SIZE=0x8000" --cpu=Cortex-M3 --predefine="-DMBED_RAM1_START=0x2007c000" --predefine="-DMBED_RAM_SIZE=0x8000" --inline --predefine="-DMBED_ROM_START=0x0" --keep=os_cb_sections
  group DebounceIn
    DebounceIn/: DebounceIn.h
  group HC_SR04_Ultrasonic_Library
    HC_SR04_Ultrasonic_Library/: ultrasonic.cpp ultrasonic.h
  group HCSR04
    HCSR04/: HCSR04.cpp HCSR04.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o ethernet_api.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_retarget.o mbed_sdk_boot.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o sys.o system_LPC17xx.o us_ticker.o
    mbed/TARGET_LPC1768/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis.h cmsis_nvic.h LPC17xx.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    mbed/: mbed.h
    mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
  group mbed-rtos
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-rtos/targets/TARGET_NXP/: mbed_rtx4.h
  group Project_Manuel
    ./: main.cpp mbed_config.h
  group USBDevice
    USBDevice/USBSerial/: CircBuffer.h USBCDC.cpp USBCDC.h USBSerial.cpp USBSerial.h
    USBDevice/USBMIDI/: MIDIMessage.h USBMIDI.cpp USBMIDI.h
    USBDevice/USBAudio/: USBAudio.cpp USBAudio.h USBAudio_Types.h
    USBDevice/USBDevice/: USBDescriptor.h USBDevice.cpp USBDevice.h USBDevice_Types.h USBEndpoints.h USBHAL.h
    USBDevice/targets/TARGET_NXP/: USBEndpoints_LPC11U.h USBEndpoints_LPC17_LPC23.h USBHAL_LPC11U.cpp USBHAL_LPC17.cpp USBHAL_LPC40.cpp
    USBDevice/USBHID/: USBHID.cpp USBHID.h USBHID_Types.h USBKeyboard.cpp USBKeyboard.h USBMouse.cpp USBMouse.h USBMouseKeyboard.cpp USBMouseKeyboard.h
    USBDevice/USBMSD/: USBMSD.cpp USBMSD.h
